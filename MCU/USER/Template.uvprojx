# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NH-CCS-MDR-MCU +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\Peripheral\inc;..\SYSTEM\misc;..\SYSTEM\uart;..\SYSTEM\flash;..\SYSTEM\systemClock;..\SYSTEM\Timer;..\SYSTEM\IIC2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c McuDataFlow.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/misc/: algorithm.c os_time_pro.c wdg.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/uart/: Uart1.c Uart2.c Uart4.c Uart5.c
    ../SYSTEM/flash/: flash.c
    ../SYSTEM/systemClock/: SysClockConfig.c
    ../SYSTEM/Timer/: Timer.c
    ../SYSTEM/IIC2/: iic2.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Peripheral
    ../Peripheral/src/: UartPrintf.c IOConf.c Beep.c FirstPower.c Mcu_SendData_Route.c Power_Ene.c RFID.c ds3231.c oled.c Finger.c test.c gui.c
